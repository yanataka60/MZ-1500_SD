		ORG		0A220H
		
		LD		HL,2003H
		LD		(0022H),HL			;MSHED
		LD		HL,2006H
		LD		(0025H),HL			;MSDAT
		LD		HL,2009H
		LD		(0028H),HL			;MLHED
		LD		HL,200CH
		LD		(002BH),HL			;MLDAT
		LD		HL,200FH
		LD		(002EH),HL			;VERIFY
		
		LD		HL,2841H
		LD		(0BE3H),HL			;DEFAULT CMT
		
		LD		HL,2003H
		LD		(289CH),HL			;MSHED
		LD		HL,2006H
		LD		(28A1H),HL			;MSDAT
		LD		HL,2009H
		LD		(28B4H),HL			;MLHED
		LD		HL,200CH
		LD		(2908H),HL			;MLDAT
		LD		HL,200FH
		LD		(2990H),HL			;VERIFY
		
		LD		HL,4C44H
		LD		DE,1361H
		LD		BC,10H
		LDIR						;AUTO RUN設定
		
		LD		HL,ENT0
		LD		DE,2000H
		LD		BC,01A0H
		LDIR						;SD_ACCRESSルーチンを転送

		JP		0000H

ENT0:								;mz-5z001_SD_ACCRESSのバイナリをここに連結
		END
